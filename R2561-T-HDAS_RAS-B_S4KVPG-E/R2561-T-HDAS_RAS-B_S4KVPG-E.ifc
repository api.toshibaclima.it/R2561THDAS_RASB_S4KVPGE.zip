Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: a00611b4-76b4-4641-ad51-d1df7bcc3087, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Project Number
Time: 2025-05-08T10:38:13+07:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.4.427 (ENU) - IFC 24.0.4.427

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 401672; RefLongitude: -71, -3, -24, -345703; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (2)
In: Building Name
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
L1 | L1 | 0
L2 | L2 | 3600

# IfcBuildingElementProxy: R2561-T-HDAS_RAS-B_S4KVPG-E:RAS-B10S4KVPG-E, R2561-T-HDAS_RAS-B_S4KVPG-E:RAS-B10S4KVPG-E:1595948
In: L1
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Carrier Air Conditioning (Thailand)
Type - Pset_ProductRequirements - Category: Electrical Equipment
Type - Pset_ProvisionForVoid - Width: 930 mm; Height: 293 mm; Depth: 255 mm
Pset_BuildingElementProxyCommon - Reference: RAS-B10S4KVPG-E; sets with these values: 2

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_1595948_1
Port_1595948_2
